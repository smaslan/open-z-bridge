* F:\Data\LVprog\Open_Z_bridge\sim\LiB_brg_4TP_twax.asc
XZ1 N036 N039 N037 N040 STDCOAX Rp={Rp1} Lp={Lp1} Rpg={Rp1r} Lpg={Lp1r} kp={kpo1} Cps={Cp1s} Rps={Rp1s} Rc={Rc1} Lc={Lc1} Rcg={Rc1r} Lcg={Lc1r} kc={kco1} Ccs={Cc1s} Rcs={Rc1s} Rs={R1} Ls={L1}
R1COAXCAB01 N028 n001COAXCAB01 {Rc3h}
L1COAXCAB01 n001COAXCAB01 n002COAXCAB01 {Lc3h}
L2COAXCAB01 n002COAXCAB01 n003COAXCAB01 {Lc3h}
R2COAXCAB01 n003COAXCAB01 n007COAXCAB01 {Rc3h}
K1COAXCAB01 L1COAXCAB01 L3COAXCAB01 {kc3}
R3COAXCAB01 N023 n004COAXCAB01 {Rc3g}
L3COAXCAB01 n004COAXCAB01 n005COAXCAB01 {Lc3g}
L4COAXCAB01 n005COAXCAB01 n006COAXCAB01 {Lc3g}
R4COAXCAB01 n006COAXCAB01 n009COAXCAB01 {Rc3g}
K2COAXCAB01 L2COAXCAB01 L4COAXCAB01 {kc3}
C1COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Cc3sh}
R5COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Rc3sh}
R6COAXCAB01 n007COAXCAB01 n008COAXCAB01 {Rc3ch}
E1COAXCAB01 n009COAXCAB01 n010COAXCAB01 n007COAXCAB01 n008COAXCAB01 1
R7COAXCAB01 n010COAXCAB01 N039 {Rc3ch}
E2COAXCAB01 n008COAXCAB01 N036 n010COAXCAB01 N039 1
R1COAXCAB02 N003 n001COAXCAB02 {Rc4h}
L1COAXCAB02 n001COAXCAB02 n002COAXCAB02 {Lc4h}
L2COAXCAB02 n002COAXCAB02 n003COAXCAB02 {Lc4h}
R2COAXCAB02 n003COAXCAB02 n007COAXCAB02 {Rc4h}
K1COAXCAB02 L1COAXCAB02 L3COAXCAB02 {kc4}
R3COAXCAB02 N018 n004COAXCAB02 {Rc4g}
L3COAXCAB02 n004COAXCAB02 n005COAXCAB02 {Lc4g}
L4COAXCAB02 n005COAXCAB02 n006COAXCAB02 {Lc4g}
R4COAXCAB02 n006COAXCAB02 n009COAXCAB02 {Rc4g}
K2COAXCAB02 L2COAXCAB02 L4COAXCAB02 {kc4}
C1COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Cc4sh}
R5COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Rc4sh}
R6COAXCAB02 n007COAXCAB02 n008COAXCAB02 {Rc4ch}
E1COAXCAB02 n009COAXCAB02 n010COAXCAB02 n007COAXCAB02 n008COAXCAB02 1
R7COAXCAB02 n010COAXCAB02 N009 {Rc4ch}
E2COAXCAB02 n008COAXCAB02 N004 n010COAXCAB02 N009 1
I1 N003 N018 {Idc} AC {Iac} 0
R1COAXCAB03 N037 n001COAXCAB03 {Rc1h}
L1COAXCAB03 n001COAXCAB03 n002COAXCAB03 {Lc1h}
L2COAXCAB03 n002COAXCAB03 n003COAXCAB03 {Lc1h}
R2COAXCAB03 n003COAXCAB03 n007COAXCAB03 {Rc1h}
K1COAXCAB03 L1COAXCAB03 L3COAXCAB03 {kc1}
R3COAXCAB03 N040 n004COAXCAB03 {Rc1g}
L3COAXCAB03 n004COAXCAB03 n005COAXCAB03 {Lc1g}
L4COAXCAB03 n005COAXCAB03 n006COAXCAB03 {Lc1g}
R4COAXCAB03 n006COAXCAB03 n009COAXCAB03 {Rc1g}
K2COAXCAB03 L2COAXCAB03 L4COAXCAB03 {kc1}
C1COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Cc1sh}
R5COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Rc1sh}
R6COAXCAB03 n007COAXCAB03 n008COAXCAB03 {Rc1ch}
E1COAXCAB03 n009COAXCAB03 n010COAXCAB03 n007COAXCAB03 n008COAXCAB03 1
R7COAXCAB03 n010COAXCAB03 N041 {Rc1ch}
E2COAXCAB03 n008COAXCAB03 N038 n010COAXCAB03 N041 1
R1GNDLUG01 N015 n001GNDLUG01 {Rgrd3}
L1GNDLUG01 n001GNDLUG01 N017 {Lgrd3}
R1GNDLUG02 N042 n001GNDLUG02 {Rgnd1}
L1GNDLUG02 n001GNDLUG02 0 {Lgnd1}
R1GNDLUG03 N018 n001GNDLUG03 {Rsrc}
L1GNDLUG03 n001GNDLUG03 0 {Lsrc}
XZ2 N005 N010 N029 N024 N004 N009 N028 N023 N035 N035 STD4TP2 Rp={Rp2} Lp={Lp2} Rpg={Rp2r} Lpg={Lp2r} kp={kpo2} Cps={Cp2s} Rps={Rp2s} Rc={Rc2} Lc={Lc2} Rcg={Rc2r} Lcg={Lc2r} kc={kco2} Ccs={Cc2s} Rcs={Rc2s} Rs={R2} Ls={L2}
R1GNDLUG04 N016 n001GNDLUG04 {Rgnd3}
L1GNDLUG04 n001GNDLUG04 0 {Lgnd3}
R1GNDLUG05 N019 n001GNDLUG05 {Rgrd2}
L1GNDLUG05 n001GNDLUG05 N020 {Lgrd2}
R1GNDLUG06 N021 n001GNDLUG06 {Rgnd2}
L1GNDLUG06 n001GNDLUG06 0 {Lgnd2}
* <component=Hpot_A>Rs=RsHpot_A Ls=LsHpot_A RsG=RsGHpot_A LsG=LsGHpot_A Mlg=MlgHpot_A Cp=CpHpot_A Rp=RpHpot_A RsS=RsSHpot_A LsS=LsSHpot_A Mls=MlsHpot_A Mgs=MgsHpot_A CpS=CpSHpot_A RpS=RpSHpot_A Mll=MllHpot_A Mgg=MggHpot_A Mlg2=Mlg2Hpot_A CpGG=CpGGHpot_A RpGG=RpGGHpot_A </component>
.param Rs2_TWAXSH01={0.5*RsHpot_A} Ls2_TWAXSH01={0.5*LsHpot_A} RsG2_TWAXSH01={0.5*RsGHpot_A} LsG2_TWAXSH01={0.5*LsGHpot_A} RsS2_TWAXSH01={0.5*RsSHpot_A} LsS2_TWAXSH01={0.5*LsSHpot_A}
.param Rnull_TWAXSH01=1e9
.param k_lg_TWAXSH01={MlgHpot_A/sqrt(LsHpot_A*LsGHpot_A)} k_ls_TWAXSH01={MlsHpot_A/sqrt(LsHpot_A*LsSHpot_A)} k_gs_TWAXSH01={MgsHpot_A/sqrt(LsGHpot_A*LsSHpot_A)} k_gg_TWAXSH01={MggHpot_A/sqrt(LsGHpot_A*LsGHpot_A)} k_ll_TWAXSH01={MllHpot_A/sqrt(LsHpot_A*LsHpot_A)} k_lg2_TWAXSH01={Mlg2Hpot_A/sqrt(LsHpot_A*LsGHpot_A)}
L1TWAXSH01 N003TWAXSH01 P001TWAXSH01 {LsG2_TWAXSH01}
L2TWAXSH01 N004TWAXSH01 P002TWAXSH01 {Ls2_TWAXSH01}
L3TWAXSH01 P003TWAXSH01 N003TWAXSH01 {LsG2_TWAXSH01}
L4TWAXSH01 P004TWAXSH01 N004TWAXSH01 {Ls2_TWAXSH01}
C1TWAXSH01 N003TWAXSH01 N004TWAXSH01 {CpHpot_A}
R1TWAXSH01 N003TWAXSH01 N004TWAXSH01 {RpHpot_A}
R2TWAXSH01 P001TWAXSH01 N001 {RsG2_TWAXSH01}
R3TWAXSH01 P002TWAXSH01 N006 {Rs2_TWAXSH01}
R4TWAXSH01 N005 P004TWAXSH01 {Rs2_TWAXSH01}
R5TWAXSH01 NC_02 P003TWAXSH01 {RsG2_TWAXSH01}
L5TWAXSH01 N001TWAXSH01 P005TWAXSH01 {Ls2_TWAXSH01}
L6TWAXSH01 N002TWAXSH01 P006TWAXSH01 {LsG2_TWAXSH01}
L7TWAXSH01 P007TWAXSH01 N001TWAXSH01 {Ls2_TWAXSH01}
L8TWAXSH01 P008TWAXSH01 N002TWAXSH01 {LsG2_TWAXSH01}
C2TWAXSH01 N001TWAXSH01 N002TWAXSH01 {CpHpot_A}
R6TWAXSH01 N001TWAXSH01 N002TWAXSH01 {RpHpot_A}
R7TWAXSH01 P005TWAXSH01 N011 {Rs2_TWAXSH01}
R8TWAXSH01 P006TWAXSH01 N014 {RsG2_TWAXSH01}
R9TWAXSH01 NC_01 P008TWAXSH01 {RsG2_TWAXSH01}
R10TWAXSH01 N010 P007TWAXSH01 {Rs2_TWAXSH01}
L9TWAXSH01 CAPTWAXSH01 P009TWAXSH01 {LsS2_TWAXSH01}
L10TWAXSH01 P010TWAXSH01 CAPTWAXSH01 {LsS2_TWAXSH01}
R11TWAXSH01 P009TWAXSH01 0 {RsS2_TWAXSH01}
R12TWAXSH01 NC_03 P010TWAXSH01 {RsS2_TWAXSH01}
C3TWAXSH01 N002TWAXSH01 CAPTWAXSH01 {CpSHpot_A}
C4TWAXSH01 CAPTWAXSH01 N003TWAXSH01 {CpSHpot_A}
R13TWAXSH01 CAPTWAXSH01 N003TWAXSH01 {RpSHpot_A}
R14TWAXSH01 N002TWAXSH01 CAPTWAXSH01 {RpSHpot_A}
C5TWAXSH01 N002TWAXSH01 N003TWAXSH01 {CpGGHpot_A}
R15TWAXSH01 N002TWAXSH01 N003TWAXSH01 {RpGGHpot_A}
R16TWAXSH01 N011 N014 {Rnull_TWAXSH01}
R17TWAXSH01 N014 0 {Rnull_TWAXSH01}
R18TWAXSH01 0 N001 {Rnull_TWAXSH01}
R19TWAXSH01 N001 N006 {Rnull_TWAXSH01}
R20TWAXSH01 NC_02 N005 {Rnull_TWAXSH01}
R21TWAXSH01 NC_03 NC_02 {Rnull_TWAXSH01}
R22TWAXSH01 NC_01 NC_03 {Rnull_TWAXSH01}
R23TWAXSH01 N010 NC_01 {Rnull_TWAXSH01}
KlaTWAXSH01 L5TWAXSH01 L6TWAXSH01 {k_lg_TWAXSH01}
KraTWAXSH01 L7TWAXSH01 L8TWAXSH01 {k_lg_TWAXSH01}
KlbTWAXSH01 L1TWAXSH01 L2TWAXSH01 {k_lg_TWAXSH01}
KrbTWAXSH01 L3TWAXSH01 L4TWAXSH01 {k_lg_TWAXSH01}
KllsaTWAXSH01 L5TWAXSH01 L9TWAXSH01 {k_ls_TWAXSH01}
KlgsaTWAXSH01 L6TWAXSH01 L9TWAXSH01 {k_gs_TWAXSH01}
KlgsbTWAXSH01 L1TWAXSH01 L9TWAXSH01 {k_gs_TWAXSH01}
KllsbTWAXSH01 L2TWAXSH01 L9TWAXSH01 {k_ls_TWAXSH01}
KlggTWAXSH01 L6TWAXSH01 L1TWAXSH01 {k_gg_TWAXSH01}
KlllTWAXSH01 L5TWAXSH01 L2TWAXSH01 {k_ll_TWAXSH01}
KlglTWAXSH01 L6TWAXSH01 L2TWAXSH01 {k_lg2_TWAXSH01}
Klgl2TWAXSH01 L5TWAXSH01 L1TWAXSH01 {k_lg2_TWAXSH01}
KrlsaTWAXSH01 L7TWAXSH01 L10TWAXSH01 {k_ls_TWAXSH01}
KrgsaTWAXSH01 L8TWAXSH01 L10TWAXSH01 {k_gs_TWAXSH01}
KrgsbTWAXSH01 L3TWAXSH01 L10TWAXSH01 {k_gs_TWAXSH01}
KrlsbTWAXSH01 L4TWAXSH01 L10TWAXSH01 {k_ls_TWAXSH01}
KrggTWAXSH01 L8TWAXSH01 L3TWAXSH01 {k_gg_TWAXSH01}
KrllTWAXSH01 L7TWAXSH01 L4TWAXSH01 {k_ll_TWAXSH01}
KrglTWAXSH01 L8TWAXSH01 L4TWAXSH01 {k_lg2_TWAXSH01}
Krgl2TWAXSH01 L7TWAXSH01 L3TWAXSH01 {k_lg2_TWAXSH01}
* <component=Lpot_A>Rs=RsLpot_A Ls=LsLpot_A RsG=RsGLpot_A LsG=LsGLpot_A Mlg=MlgLpot_A Cp=CpLpot_A Rp=RpLpot_A RsS=RsSLpot_A LsS=LsSLpot_A Mls=MlsLpot_A Mgs=MgsLpot_A CpS=CpSLpot_A RpS=RpSLpot_A Mll=MllLpot_A Mgg=MggLpot_A Mlg2=Mlg2Lpot_A CpGG=CpGGLpot_A RpGG=RpGGLpot_A </component>
.param Rs2_TWAXSH02={0.5*RsLpot_A} Ls2_TWAXSH02={0.5*LsLpot_A} RsG2_TWAXSH02={0.5*RsGLpot_A} LsG2_TWAXSH02={0.5*LsGLpot_A} RsS2_TWAXSH02={0.5*RsSLpot_A} LsS2_TWAXSH02={0.5*LsSLpot_A}
.param Rnull_TWAXSH02=1e9
.param k_lg_TWAXSH02={MlgLpot_A/sqrt(LsLpot_A*LsGLpot_A)} k_ls_TWAXSH02={MlsLpot_A/sqrt(LsLpot_A*LsSLpot_A)} k_gs_TWAXSH02={MgsLpot_A/sqrt(LsGLpot_A*LsSLpot_A)} k_gg_TWAXSH02={MggLpot_A/sqrt(LsGLpot_A*LsGLpot_A)} k_ll_TWAXSH02={MllLpot_A/sqrt(LsLpot_A*LsLpot_A)} k_lg2_TWAXSH02={Mlg2Lpot_A/sqrt(LsLpot_A*LsGLpot_A)}
L1TWAXSH02 N003TWAXSH02 P001TWAXSH02 {LsG2_TWAXSH02}
L2TWAXSH02 N004TWAXSH02 P002TWAXSH02 {Ls2_TWAXSH02}
L3TWAXSH02 P003TWAXSH02 N003TWAXSH02 {LsG2_TWAXSH02}
L4TWAXSH02 P004TWAXSH02 N004TWAXSH02 {Ls2_TWAXSH02}
C1TWAXSH02 N003TWAXSH02 N004TWAXSH02 {CpLpot_A}
R1TWAXSH02 N003TWAXSH02 N004TWAXSH02 {RpLpot_A}
R2TWAXSH02 P001TWAXSH02 NC_05 {RsG2_TWAXSH02}
R3TWAXSH02 P002TWAXSH02 N029 {Rs2_TWAXSH02}
R4TWAXSH02 N030 P004TWAXSH02 {Rs2_TWAXSH02}
R5TWAXSH02 N033 P003TWAXSH02 {RsG2_TWAXSH02}
L5TWAXSH02 N001TWAXSH02 P005TWAXSH02 {Ls2_TWAXSH02}
L6TWAXSH02 N002TWAXSH02 P006TWAXSH02 {LsG2_TWAXSH02}
L7TWAXSH02 P007TWAXSH02 N001TWAXSH02 {Ls2_TWAXSH02}
L8TWAXSH02 P008TWAXSH02 N002TWAXSH02 {LsG2_TWAXSH02}
C2TWAXSH02 N001TWAXSH02 N002TWAXSH02 {CpLpot_A}
R6TWAXSH02 N001TWAXSH02 N002TWAXSH02 {RpLpot_A}
R7TWAXSH02 P005TWAXSH02 N024 {Rs2_TWAXSH02}
R8TWAXSH02 P006TWAXSH02 NC_04 {RsG2_TWAXSH02}
R9TWAXSH02 N022 P008TWAXSH02 {RsG2_TWAXSH02}
R10TWAXSH02 N025 P007TWAXSH02 {Rs2_TWAXSH02}
L9TWAXSH02 CAPTWAXSH02 P009TWAXSH02 {LsS2_TWAXSH02}
L10TWAXSH02 P010TWAXSH02 CAPTWAXSH02 {LsS2_TWAXSH02}
R11TWAXSH02 P009TWAXSH02 NC_06 {RsS2_TWAXSH02}
R12TWAXSH02 0 P010TWAXSH02 {RsS2_TWAXSH02}
C3TWAXSH02 N002TWAXSH02 CAPTWAXSH02 {CpSLpot_A}
C4TWAXSH02 CAPTWAXSH02 N003TWAXSH02 {CpSLpot_A}
R13TWAXSH02 CAPTWAXSH02 N003TWAXSH02 {RpSLpot_A}
R14TWAXSH02 N002TWAXSH02 CAPTWAXSH02 {RpSLpot_A}
C5TWAXSH02 N002TWAXSH02 N003TWAXSH02 {CpGGLpot_A}
R15TWAXSH02 N002TWAXSH02 N003TWAXSH02 {RpGGLpot_A}
R16TWAXSH02 N024 NC_04 {Rnull_TWAXSH02}
R17TWAXSH02 NC_04 NC_06 {Rnull_TWAXSH02}
R18TWAXSH02 NC_06 NC_05 {Rnull_TWAXSH02}
R19TWAXSH02 NC_05 N029 {Rnull_TWAXSH02}
R20TWAXSH02 N033 N030 {Rnull_TWAXSH02}
R21TWAXSH02 0 N033 {Rnull_TWAXSH02}
R22TWAXSH02 N022 0 {Rnull_TWAXSH02}
R23TWAXSH02 N025 N022 {Rnull_TWAXSH02}
KlaTWAXSH02 L5TWAXSH02 L6TWAXSH02 {k_lg_TWAXSH02}
KraTWAXSH02 L7TWAXSH02 L8TWAXSH02 {k_lg_TWAXSH02}
KlbTWAXSH02 L1TWAXSH02 L2TWAXSH02 {k_lg_TWAXSH02}
KrbTWAXSH02 L3TWAXSH02 L4TWAXSH02 {k_lg_TWAXSH02}
KllsaTWAXSH02 L5TWAXSH02 L9TWAXSH02 {k_ls_TWAXSH02}
KlgsaTWAXSH02 L6TWAXSH02 L9TWAXSH02 {k_gs_TWAXSH02}
KlgsbTWAXSH02 L1TWAXSH02 L9TWAXSH02 {k_gs_TWAXSH02}
KllsbTWAXSH02 L2TWAXSH02 L9TWAXSH02 {k_ls_TWAXSH02}
KlggTWAXSH02 L6TWAXSH02 L1TWAXSH02 {k_gg_TWAXSH02}
KlllTWAXSH02 L5TWAXSH02 L2TWAXSH02 {k_ll_TWAXSH02}
KlglTWAXSH02 L6TWAXSH02 L2TWAXSH02 {k_lg2_TWAXSH02}
Klgl2TWAXSH02 L5TWAXSH02 L1TWAXSH02 {k_lg2_TWAXSH02}
KrlsaTWAXSH02 L7TWAXSH02 L10TWAXSH02 {k_ls_TWAXSH02}
KrgsaTWAXSH02 L8TWAXSH02 L10TWAXSH02 {k_gs_TWAXSH02}
KrgsbTWAXSH02 L3TWAXSH02 L10TWAXSH02 {k_gs_TWAXSH02}
KrlsbTWAXSH02 L4TWAXSH02 L10TWAXSH02 {k_ls_TWAXSH02}
KrggTWAXSH02 L8TWAXSH02 L3TWAXSH02 {k_gg_TWAXSH02}
KrllTWAXSH02 L7TWAXSH02 L4TWAXSH02 {k_ll_TWAXSH02}
KrglTWAXSH02 L8TWAXSH02 L4TWAXSH02 {k_lg2_TWAXSH02}
Krgl2TWAXSH02 L7TWAXSH02 L3TWAXSH02 {k_lg2_TWAXSH02}
* <component=buf_hpot>CgA=CgA_buf_hpot RgA=RgA_buf_hpot CgB=CgB_buf_hpot RgB=RgB_buf_hpot LoA=LoA_buf_hpot RoA=RoA_buf_hpot LoB=LoB_buf_hpot RoB=RoB_buf_hpot </component>
Xbuf_hpot N006 N001 N011 N014 N007 N002 N012 N015 0 DUAL_EPBUF CgA={CgA_buf_hpot} RgA={RgA_buf_hpot} CgB={CgB_buf_hpot} RgB={RgB_buf_hpot} LoA={LoA_buf_hpot} RoA={RoA_buf_hpot} LoB={LoB_buf_hpot} RoB={RoB_buf_hpot}
* <component=buf_lpot>CgA=CgA_buf_lpot RgA=RgA_buf_lpot CgB=CgB_buf_lpot RgB=RgB_buf_lpot LoA=LoA_buf_lpot RoA=RoA_buf_lpot LoB=LoB_buf_lpot RoB=RoB_buf_lpot </component>
Xbuf_lpot N031 N034 N026 N019 N030 N033 N025 N022 0 DUAL_EPBUF CgA={CgA_buf_lpot} RgA={RgA_buf_lpot} CgB={CgB_buf_lpot} RgB={RgB_buf_lpot} LoA={LoA_buf_lpot} RoA={RoA_buf_lpot} LoB={LoB_buf_lpot} RoB={RoB_buf_lpot}
* <component=Hpot_B>Rs=RsHpot_B Ls=LsHpot_B RsG=RsGHpot_B LsG=LsGHpot_B Mlg=MlgHpot_B Cp=CpHpot_B Rp=RpHpot_B RsS=RsSHpot_B LsS=LsSHpot_B Mls=MlsHpot_B Mgs=MgsHpot_B CpS=CpSHpot_B RpS=RpSHpot_B Mll=MllHpot_B Mgg=MggHpot_B Mlg2=Mlg2Hpot_B CpGG=CpGGHpot_B RpGG=RpGGHpot_B </component>
.param Rs2_TWAXSH03={0.5*RsHpot_B} Ls2_TWAXSH03={0.5*LsHpot_B} RsG2_TWAXSH03={0.5*RsGHpot_B} LsG2_TWAXSH03={0.5*LsGHpot_B} RsS2_TWAXSH03={0.5*RsSHpot_B} LsS2_TWAXSH03={0.5*LsSHpot_B}
.param Rnull_TWAXSH03=1e9
.param k_lg_TWAXSH03={MlgHpot_B/sqrt(LsHpot_B*LsGHpot_B)} k_ls_TWAXSH03={MlsHpot_B/sqrt(LsHpot_B*LsSHpot_B)} k_gs_TWAXSH03={MgsHpot_B/sqrt(LsGHpot_B*LsSHpot_B)} k_gg_TWAXSH03={MggHpot_B/sqrt(LsGHpot_B*LsGHpot_B)} k_ll_TWAXSH03={MllHpot_B/sqrt(LsHpot_B*LsHpot_B)} k_lg2_TWAXSH03={Mlg2Hpot_B/sqrt(LsHpot_B*LsGHpot_B)}
L1TWAXSH03 N003TWAXSH03 P001TWAXSH03 {LsG2_TWAXSH03}
L2TWAXSH03 N004TWAXSH03 P002TWAXSH03 {Ls2_TWAXSH03}
L3TWAXSH03 P003TWAXSH03 N003TWAXSH03 {LsG2_TWAXSH03}
L4TWAXSH03 P004TWAXSH03 N004TWAXSH03 {Ls2_TWAXSH03}
C1TWAXSH03 N003TWAXSH03 N004TWAXSH03 {CpHpot_B}
R1TWAXSH03 N003TWAXSH03 N004TWAXSH03 {RpHpot_B}
R2TWAXSH03 P001TWAXSH03 NC_08 {RsG2_TWAXSH03}
R3TWAXSH03 P002TWAXSH03 N008 {Rs2_TWAXSH03}
R4TWAXSH03 N007 P004TWAXSH03 {Rs2_TWAXSH03}
R5TWAXSH03 N002 P003TWAXSH03 {RsG2_TWAXSH03}
L5TWAXSH03 N001TWAXSH03 P005TWAXSH03 {Ls2_TWAXSH03}
L6TWAXSH03 N002TWAXSH03 P006TWAXSH03 {LsG2_TWAXSH03}
L7TWAXSH03 P007TWAXSH03 N001TWAXSH03 {Ls2_TWAXSH03}
L8TWAXSH03 P008TWAXSH03 N002TWAXSH03 {LsG2_TWAXSH03}
C2TWAXSH03 N001TWAXSH03 N002TWAXSH03 {CpHpot_B}
R6TWAXSH03 N001TWAXSH03 N002TWAXSH03 {RpHpot_B}
R7TWAXSH03 P005TWAXSH03 N013 {Rs2_TWAXSH03}
R8TWAXSH03 P006TWAXSH03 NC_07 {RsG2_TWAXSH03}
R9TWAXSH03 N015 P008TWAXSH03 {RsG2_TWAXSH03}
R10TWAXSH03 N012 P007TWAXSH03 {Rs2_TWAXSH03}
L9TWAXSH03 CAPTWAXSH03 P009TWAXSH03 {LsS2_TWAXSH03}
L10TWAXSH03 P010TWAXSH03 CAPTWAXSH03 {LsS2_TWAXSH03}
R11TWAXSH03 P009TWAXSH03 NC_09 {RsS2_TWAXSH03}
R12TWAXSH03 0 P010TWAXSH03 {RsS2_TWAXSH03}
C3TWAXSH03 N002TWAXSH03 CAPTWAXSH03 {CpSHpot_B}
C4TWAXSH03 CAPTWAXSH03 N003TWAXSH03 {CpSHpot_B}
R13TWAXSH03 CAPTWAXSH03 N003TWAXSH03 {RpSHpot_B}
R14TWAXSH03 N002TWAXSH03 CAPTWAXSH03 {RpSHpot_B}
C5TWAXSH03 N002TWAXSH03 N003TWAXSH03 {CpGGHpot_B}
R15TWAXSH03 N002TWAXSH03 N003TWAXSH03 {RpGGHpot_B}
R16TWAXSH03 N013 NC_07 {Rnull_TWAXSH03}
R17TWAXSH03 NC_07 NC_09 {Rnull_TWAXSH03}
R18TWAXSH03 NC_09 NC_08 {Rnull_TWAXSH03}
R19TWAXSH03 NC_08 N008 {Rnull_TWAXSH03}
R20TWAXSH03 N002 N007 {Rnull_TWAXSH03}
R21TWAXSH03 0 N002 {Rnull_TWAXSH03}
R22TWAXSH03 N015 0 {Rnull_TWAXSH03}
R23TWAXSH03 N012 N015 {Rnull_TWAXSH03}
KlaTWAXSH03 L5TWAXSH03 L6TWAXSH03 {k_lg_TWAXSH03}
KraTWAXSH03 L7TWAXSH03 L8TWAXSH03 {k_lg_TWAXSH03}
KlbTWAXSH03 L1TWAXSH03 L2TWAXSH03 {k_lg_TWAXSH03}
KrbTWAXSH03 L3TWAXSH03 L4TWAXSH03 {k_lg_TWAXSH03}
KllsaTWAXSH03 L5TWAXSH03 L9TWAXSH03 {k_ls_TWAXSH03}
KlgsaTWAXSH03 L6TWAXSH03 L9TWAXSH03 {k_gs_TWAXSH03}
KlgsbTWAXSH03 L1TWAXSH03 L9TWAXSH03 {k_gs_TWAXSH03}
KllsbTWAXSH03 L2TWAXSH03 L9TWAXSH03 {k_ls_TWAXSH03}
KlggTWAXSH03 L6TWAXSH03 L1TWAXSH03 {k_gg_TWAXSH03}
KlllTWAXSH03 L5TWAXSH03 L2TWAXSH03 {k_ll_TWAXSH03}
KlglTWAXSH03 L6TWAXSH03 L2TWAXSH03 {k_lg2_TWAXSH03}
Klgl2TWAXSH03 L5TWAXSH03 L1TWAXSH03 {k_lg2_TWAXSH03}
KrlsaTWAXSH03 L7TWAXSH03 L10TWAXSH03 {k_ls_TWAXSH03}
KrgsaTWAXSH03 L8TWAXSH03 L10TWAXSH03 {k_gs_TWAXSH03}
KrgsbTWAXSH03 L3TWAXSH03 L10TWAXSH03 {k_gs_TWAXSH03}
KrlsbTWAXSH03 L4TWAXSH03 L10TWAXSH03 {k_ls_TWAXSH03}
KrggTWAXSH03 L8TWAXSH03 L3TWAXSH03 {k_gg_TWAXSH03}
KrllTWAXSH03 L7TWAXSH03 L4TWAXSH03 {k_ll_TWAXSH03}
KrglTWAXSH03 L8TWAXSH03 L4TWAXSH03 {k_lg2_TWAXSH03}
Krgl2TWAXSH03 L7TWAXSH03 L3TWAXSH03 {k_lg2_TWAXSH03}
* <component=Lpot_B>Rs=RsLpot_B Ls=LsLpot_B RsG=RsGLpot_B LsG=LsGLpot_B Mlg=MlgLpot_B Cp=CpLpot_B Rp=RpLpot_B RsS=RsSLpot_B LsS=LsSLpot_B Mls=MlsLpot_B Mgs=MgsLpot_B CpS=CpSLpot_B RpS=RpSLpot_B Mll=MllLpot_B Mgg=MggLpot_B Mlg2=Mlg2Lpot_B CpGG=CpGGLpot_B RpGG=RpGGLpot_B </component>
.param Rs2_TWAXSH04={0.5*RsLpot_B} Ls2_TWAXSH04={0.5*LsLpot_B} RsG2_TWAXSH04={0.5*RsGLpot_B} LsG2_TWAXSH04={0.5*LsGLpot_B} RsS2_TWAXSH04={0.5*RsSLpot_B} LsS2_TWAXSH04={0.5*LsSLpot_B}
.param Rnull_TWAXSH04=1e9
.param k_lg_TWAXSH04={MlgLpot_B/sqrt(LsLpot_B*LsGLpot_B)} k_ls_TWAXSH04={MlsLpot_B/sqrt(LsLpot_B*LsSLpot_B)} k_gs_TWAXSH04={MgsLpot_B/sqrt(LsGLpot_B*LsSLpot_B)} k_gg_TWAXSH04={MggLpot_B/sqrt(LsGLpot_B*LsGLpot_B)} k_ll_TWAXSH04={MllLpot_B/sqrt(LsLpot_B*LsLpot_B)} k_lg2_TWAXSH04={Mlg2Lpot_B/sqrt(LsLpot_B*LsGLpot_B)}
L1TWAXSH04 N003TWAXSH04 P001TWAXSH04 {LsG2_TWAXSH04}
L2TWAXSH04 N004TWAXSH04 P002TWAXSH04 {Ls2_TWAXSH04}
L3TWAXSH04 P003TWAXSH04 N003TWAXSH04 {LsG2_TWAXSH04}
L4TWAXSH04 P004TWAXSH04 N004TWAXSH04 {Ls2_TWAXSH04}
C1TWAXSH04 N003TWAXSH04 N004TWAXSH04 {CpLpot_B}
R1TWAXSH04 N003TWAXSH04 N004TWAXSH04 {RpLpot_B}
R2TWAXSH04 P001TWAXSH04 N034 {RsG2_TWAXSH04}
R3TWAXSH04 P002TWAXSH04 N031 {Rs2_TWAXSH04}
R4TWAXSH04 N032 P004TWAXSH04 {Rs2_TWAXSH04}
R5TWAXSH04 NC_11 P003TWAXSH04 {RsG2_TWAXSH04}
L5TWAXSH04 N001TWAXSH04 P005TWAXSH04 {Ls2_TWAXSH04}
L6TWAXSH04 N002TWAXSH04 P006TWAXSH04 {LsG2_TWAXSH04}
L7TWAXSH04 P007TWAXSH04 N001TWAXSH04 {Ls2_TWAXSH04}
L8TWAXSH04 P008TWAXSH04 N002TWAXSH04 {LsG2_TWAXSH04}
C2TWAXSH04 N001TWAXSH04 N002TWAXSH04 {CpLpot_B}
R6TWAXSH04 N001TWAXSH04 N002TWAXSH04 {RpLpot_B}
R7TWAXSH04 P005TWAXSH04 N026 {Rs2_TWAXSH04}
R8TWAXSH04 P006TWAXSH04 N019 {RsG2_TWAXSH04}
R9TWAXSH04 NC_10 P008TWAXSH04 {RsG2_TWAXSH04}
R10TWAXSH04 N027 P007TWAXSH04 {Rs2_TWAXSH04}
L9TWAXSH04 CAPTWAXSH04 P009TWAXSH04 {LsS2_TWAXSH04}
L10TWAXSH04 P010TWAXSH04 CAPTWAXSH04 {LsS2_TWAXSH04}
R11TWAXSH04 P009TWAXSH04 0 {RsS2_TWAXSH04}
R12TWAXSH04 NC_12 P010TWAXSH04 {RsS2_TWAXSH04}
C3TWAXSH04 N002TWAXSH04 CAPTWAXSH04 {CpSLpot_B}
C4TWAXSH04 CAPTWAXSH04 N003TWAXSH04 {CpSLpot_B}
R13TWAXSH04 CAPTWAXSH04 N003TWAXSH04 {RpSLpot_B}
R14TWAXSH04 N002TWAXSH04 CAPTWAXSH04 {RpSLpot_B}
C5TWAXSH04 N002TWAXSH04 N003TWAXSH04 {CpGGLpot_B}
R15TWAXSH04 N002TWAXSH04 N003TWAXSH04 {RpGGLpot_B}
R16TWAXSH04 N026 N019 {Rnull_TWAXSH04}
R17TWAXSH04 N019 0 {Rnull_TWAXSH04}
R18TWAXSH04 0 N034 {Rnull_TWAXSH04}
R19TWAXSH04 N034 N031 {Rnull_TWAXSH04}
R20TWAXSH04 NC_11 N032 {Rnull_TWAXSH04}
R21TWAXSH04 NC_12 NC_11 {Rnull_TWAXSH04}
R22TWAXSH04 NC_10 NC_12 {Rnull_TWAXSH04}
R23TWAXSH04 N027 NC_10 {Rnull_TWAXSH04}
KlaTWAXSH04 L5TWAXSH04 L6TWAXSH04 {k_lg_TWAXSH04}
KraTWAXSH04 L7TWAXSH04 L8TWAXSH04 {k_lg_TWAXSH04}
KlbTWAXSH04 L1TWAXSH04 L2TWAXSH04 {k_lg_TWAXSH04}
KrbTWAXSH04 L3TWAXSH04 L4TWAXSH04 {k_lg_TWAXSH04}
KllsaTWAXSH04 L5TWAXSH04 L9TWAXSH04 {k_ls_TWAXSH04}
KlgsaTWAXSH04 L6TWAXSH04 L9TWAXSH04 {k_gs_TWAXSH04}
KlgsbTWAXSH04 L1TWAXSH04 L9TWAXSH04 {k_gs_TWAXSH04}
KllsbTWAXSH04 L2TWAXSH04 L9TWAXSH04 {k_ls_TWAXSH04}
KlggTWAXSH04 L6TWAXSH04 L1TWAXSH04 {k_gg_TWAXSH04}
KlllTWAXSH04 L5TWAXSH04 L2TWAXSH04 {k_ll_TWAXSH04}
KlglTWAXSH04 L6TWAXSH04 L2TWAXSH04 {k_lg2_TWAXSH04}
Klgl2TWAXSH04 L5TWAXSH04 L1TWAXSH04 {k_lg2_TWAXSH04}
KrlsaTWAXSH04 L7TWAXSH04 L10TWAXSH04 {k_ls_TWAXSH04}
KrgsaTWAXSH04 L8TWAXSH04 L10TWAXSH04 {k_gs_TWAXSH04}
KrgsbTWAXSH04 L3TWAXSH04 L10TWAXSH04 {k_gs_TWAXSH04}
KrlsbTWAXSH04 L4TWAXSH04 L10TWAXSH04 {k_ls_TWAXSH04}
KrggTWAXSH04 L8TWAXSH04 L3TWAXSH04 {k_gg_TWAXSH04}
KrllTWAXSH04 L7TWAXSH04 L4TWAXSH04 {k_ll_TWAXSH04}
KrglTWAXSH04 L8TWAXSH04 L4TWAXSH04 {k_lg2_TWAXSH04}
Krgl2TWAXSH04 L7TWAXSH04 L3TWAXSH04 {k_lg2_TWAXSH04}
XADC3 N008 N013 N017 N016 U3_adc_high 0 DIG3458 Ci={C3in} Ri={R3in} Clg={C3sh} Rlg={R3sh} Cgs={C3gnd} Rgs={R3gnd}
XADC2 N032 N027 N020 N021 U2_adc_high 0 DIG3458 Ci={C2in} Ri={R2in} Clg={C2sh} Rlg={R2sh} Cgs={C2gnd} Rgs={R2gnd}
XADC1 N038 N041 N043 N042 U1_adc_high 0 DIG3458 Ci={C1in} Ri={R1in} Clg={C1sh} Rlg={R1sh} Cgs={C1gnd} Rgs={R1gnd}
R1GNDLUG07 N039 n001GNDLUG07 {Rgrd2}
L1GNDLUG07 n001GNDLUG07 N043 {Lgrd2}
* <twax>\n  Rs={Rs%} Ls={Ls%} RsG={RsG%} LsG={LsG%} Mlg={Mlg%} Cp={Cp%} Rp={Rp%}\n  RsS={RsS%} LsS={LsS%} Mls={Mls%} Mgs={Mgs%} CpS={CpS%} RpS={RpS%}\n  Mll={Mll%} Mgg={Mgg%} Mlg2={Mlg2%} CpGG={CpGG%} RpGG={RpGG%}\n</twax>
* <epbuf>\n  CgA={CgA_%} RgA={RgA_%} CgB={CgB_%} RgB={RgB_%}\n  LoA={LoA_%} RoA={RoA_%} LoB={LoB_%} RoB={RoB_%}\n</epbuf>
.lib ZbrgLib.cir ZbrgLib

* Automatically generated stray couplings

.end

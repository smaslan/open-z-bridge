* F:\Data\LVprog\Open_Z_bridge\sim\LiB_brg.asc
XZ1 N017 N019 N018 N020 STDCOAX Rp={Rp1} Lp={Lp1} Rpg={Rp1r} Lpg={Lp1r} kp={kpo1} Cps={Cp1s} Rps={Rp1s} Rc={Rc1} Lc={Lc1} Rcg={Rc1r} Lcg={Lc1r} kc={kco1} Ccs={Cc1s} Rcs={Rc1s} Rs={R1} Ls={L1}
R1COAXCAB01 N014 n001COAXCAB01 {Rc3h}
L1COAXCAB01 n001COAXCAB01 n002COAXCAB01 {Lc3h}
L2COAXCAB01 n002COAXCAB01 n003COAXCAB01 {Lc3h}
R2COAXCAB01 n003COAXCAB01 n007COAXCAB01 {Rc3h}
K1COAXCAB01 L1COAXCAB01 L3COAXCAB01 {kc3}
R3COAXCAB01 N012 n004COAXCAB01 {Rc3g}
L3COAXCAB01 n004COAXCAB01 n005COAXCAB01 {Lc3g}
L4COAXCAB01 n005COAXCAB01 n006COAXCAB01 {Lc3g}
R4COAXCAB01 n006COAXCAB01 n009COAXCAB01 {Rc3g}
K2COAXCAB01 L2COAXCAB01 L4COAXCAB01 {kc3}
C1COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Cc3sh}
R5COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Rc3sh}
R6COAXCAB01 n007COAXCAB01 n008COAXCAB01 {Rc3ch}
E1COAXCAB01 n009COAXCAB01 n010COAXCAB01 n007COAXCAB01 n008COAXCAB01 1
R7COAXCAB01 n010COAXCAB01 N019 {Rc3ch}
E2COAXCAB01 n008COAXCAB01 N017 n010COAXCAB01 N019 1
R1COAXCAB02 N004 n001COAXCAB02 {Rc4h}
L1COAXCAB02 n001COAXCAB02 n002COAXCAB02 {Lc4h}
L2COAXCAB02 n002COAXCAB02 n003COAXCAB02 {Lc4h}
R2COAXCAB02 n003COAXCAB02 n007COAXCAB02 {Rc4h}
K1COAXCAB02 L1COAXCAB02 L3COAXCAB02 {kc4}
R3COAXCAB02 N010 n004COAXCAB02 {Rc4g}
L3COAXCAB02 n004COAXCAB02 n005COAXCAB02 {Lc4g}
L4COAXCAB02 n005COAXCAB02 n006COAXCAB02 {Lc4g}
R4COAXCAB02 n006COAXCAB02 n009COAXCAB02 {Rc4g}
K2COAXCAB02 L2COAXCAB02 L4COAXCAB02 {kc4}
C1COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Cc4sh}
R5COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Rc4sh}
R6COAXCAB02 n007COAXCAB02 n008COAXCAB02 {Rc4ch}
E1COAXCAB02 n009COAXCAB02 n010COAXCAB02 n007COAXCAB02 n008COAXCAB02 1
R7COAXCAB02 n010COAXCAB02 N008 {Rc4ch}
E2COAXCAB02 n008COAXCAB02 N005 n010COAXCAB02 N008 1
I1 N004 N010 {Idc} AC {Iac} 0
R1COAXCAB03 U2_adc_high n001COAXCAB03 {Rc2h}
L1COAXCAB03 n001COAXCAB03 n002COAXCAB03 {Lc2h}
L2COAXCAB03 n002COAXCAB03 n003COAXCAB03 {Lc2h}
R2COAXCAB03 n003COAXCAB03 n007COAXCAB03 {Rc2h}
K1COAXCAB03 L1COAXCAB03 L3COAXCAB03 {kc2}
R3COAXCAB03 U2_adc_low n004COAXCAB03 {Rc2g}
L3COAXCAB03 n004COAXCAB03 n005COAXCAB03 {Lc2g}
L4COAXCAB03 n005COAXCAB03 n006COAXCAB03 {Lc2g}
R4COAXCAB03 n006COAXCAB03 n009COAXCAB03 {Rc2g}
K2COAXCAB03 L2COAXCAB03 L4COAXCAB03 {kc2}
C1COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Cc2sh}
R5COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Rc2sh}
R6COAXCAB03 n007COAXCAB03 n008COAXCAB03 {Rc2ch}
E1COAXCAB03 n009COAXCAB03 n010COAXCAB03 n007COAXCAB03 n008COAXCAB03 1
R7COAXCAB03 n010COAXCAB03 N007 {Rc2ch}
E2COAXCAB03 n008COAXCAB03 N011 n010COAXCAB03 N007 1
R1 N009 N013 100Meg
R1GNDLUG01 N006 n001GNDLUG01 {Rpc1}
L1GNDLUG01 n001GNDLUG01 N007 {Lpc1}
R1GNDLUG02 N015 n001GNDLUG02 {Rpc2}
L1GNDLUG02 n001GNDLUG02 N011 {Lpc2}
R1COAXCAB04 N018 n001COAXCAB04 {Rc1h}
L1COAXCAB04 n001COAXCAB04 n002COAXCAB04 {Lc1h}
L2COAXCAB04 n002COAXCAB04 n003COAXCAB04 {Lc1h}
R2COAXCAB04 n003COAXCAB04 n007COAXCAB04 {Rc1h}
K1COAXCAB04 L1COAXCAB04 L3COAXCAB04 {kc1}
R3COAXCAB04 N020 n004COAXCAB04 {Rc1g}
L3COAXCAB04 n004COAXCAB04 n005COAXCAB04 {Lc1g}
L4COAXCAB04 n005COAXCAB04 n006COAXCAB04 {Lc1g}
R4COAXCAB04 n006COAXCAB04 n009COAXCAB04 {Rc1g}
K2COAXCAB04 L2COAXCAB04 L4COAXCAB04 {kc1}
C1COAXCAB04 n002COAXCAB04 n005COAXCAB04 {Cc1sh}
R5COAXCAB04 n002COAXCAB04 n005COAXCAB04 {Rc1sh}
R6COAXCAB04 n007COAXCAB04 n008COAXCAB04 {Rc1ch}
E1COAXCAB04 n009COAXCAB04 n010COAXCAB04 n007COAXCAB04 n008COAXCAB04 1
R7COAXCAB04 n010COAXCAB04 U1_adc_low {Rc1ch}
E2COAXCAB04 n008COAXCAB04 U1_adc_high n010COAXCAB04 U1_adc_low 1
C2 U2_adc_low U2_adc_high {C2in}
R3 U2_adc_low U2_adc_high {R2in}
C5 U2_adc_low N003 {C2sh}
R4 U2_adc_low N003 {R2sh}
C6 U1_adc_high U1_adc_low {C1in}
R5 U1_adc_high U1_adc_low {R1in}
C9 U1_adc_low N021 {C1sh}
R6 U1_adc_low N021 {R1sh}
R1GNDLUG03 N002 n001GNDLUG03 {Rgrd2}
L1GNDLUG03 n001GNDLUG03 N003 {Lgrd2}
R1GNDLUG04 N021 n001GNDLUG04 {Rgnd1}
L1GNDLUG04 n001GNDLUG04 0 {Lgnd1}
R1GNDLUG05 N010 n001GNDLUG05 {Rsrc}
L1GNDLUG05 n001GNDLUG05 0 {Lsrc}
XZ2 N006 N009 N015 N013 N005 N008 N014 N012 N016 N016 STD4TP2 Rp={Rp2} Lp={Lp2} Rpg={Rp2r} Lpg={Lp2r} kp={kpo2} Cps={Cp2s} Rps={Rp2s} Rc={Rc2} Lc={Lc2} Rcg={Rc2r} Lcg={Lc2r} kc={kco2} Ccs={Cc2s} Rcs={Rc2s} Rs={R2} Ls={L2}
E1 N002 0 U2_adc_low 0 1
R2 N003 N001 {R2gnd}
C1 N003 N001 {C2gnd}
R1GNDLUG06 0 n001GNDLUG06 {Rgnd2}
L1GNDLUG06 n001GNDLUG06 N001 {Lgnd2}
C3 U2_adc_low 0 {C2buf}
R7 U2_adc_low 0 {R2buf}
.lib ZbrgLib.cir ZbrgLib

* Automatically generated stray couplings
.param k_stray001={max(min(M_stray01/sqrt(abs(Lc1h*Lc2h)),0.999),-0.999)} $ #01=<M_stray01> - #stray_group_id=<mutual_inductance_parameter>
Kstray0001 L1COAXCAB04 L1COAXCAB03 {k_stray001}
.param k_stray002={max(min(M_stray01/sqrt(abs(Lc1g*Lc2g)),0.999),-0.999)} $ #01=<M_stray01> - #stray_group_id=<mutual_inductance_parameter>
Kstray0002 L3COAXCAB04 L3COAXCAB03 {k_stray002}
.param k_stray003={max(min(M_stray01/sqrt(abs(Lc1h*Lc2g)),0.999),-0.999)} $ #01=<M_stray01> - #stray_group_id=<mutual_inductance_parameter>
Kstray0003 L1COAXCAB04 L3COAXCAB03 {k_stray003}
.param k_stray004={max(min(M_stray01/sqrt(abs(Lc1g*Lc2h)),0.999),-0.999)} $ #01=<M_stray01> - #stray_group_id=<mutual_inductance_parameter>
Kstray0004 L3COAXCAB04 L1COAXCAB03 {k_stray004}

.end

* F:\Data\LVprog\Open_Z_bridge\sim\LiB_brg2.asc
XZ1 N018 N020 N019 N021 STDCOAX Rp={Rp1} Lp={Lp1} Rpg={Rp1r} Lpg={Lp1r} kp={kpo1} Cps={Cp1s} Rps={Rp1s} Rc={Rc1} Lc={Lc1} Rcg={Rc1r} Lcg={Lc1r} kc={kco1} Ccs={Cc1s} Rcs={Rc1s} Rs={R1} Ls={L1}
R1COAXCAB01 N012 n001COAXCAB01 {Rc3h}
L1COAXCAB01 n001COAXCAB01 n002COAXCAB01 {Lc3h}
L2COAXCAB01 n002COAXCAB01 n003COAXCAB01 {Lc3h}
R2COAXCAB01 n003COAXCAB01 n007COAXCAB01 {Rc3h}
K1COAXCAB01 L1COAXCAB01 L3COAXCAB01 {kc3}
R3COAXCAB01 N010 n004COAXCAB01 {Rc3g}
L3COAXCAB01 n004COAXCAB01 n005COAXCAB01 {Lc3g}
L4COAXCAB01 n005COAXCAB01 n006COAXCAB01 {Lc3g}
R4COAXCAB01 n006COAXCAB01 n009COAXCAB01 {Rc3g}
K2COAXCAB01 L2COAXCAB01 L4COAXCAB01 {kc3}
C1COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Cc3sh}
R5COAXCAB01 n002COAXCAB01 n005COAXCAB01 {Rc3sh}
R6COAXCAB01 n007COAXCAB01 n008COAXCAB01 {Rc3ch}
E1COAXCAB01 n009COAXCAB01 n010COAXCAB01 n007COAXCAB01 n008COAXCAB01 1
R7COAXCAB01 n010COAXCAB01 N020 {Rc3ch}
E2COAXCAB01 n008COAXCAB01 N018 n010COAXCAB01 N020 1
R1COAXCAB02 N004 n001COAXCAB02 {Rc4h}
L1COAXCAB02 n001COAXCAB02 n002COAXCAB02 {Lc4h}
L2COAXCAB02 n002COAXCAB02 n003COAXCAB02 {Lc4h}
R2COAXCAB02 n003COAXCAB02 n007COAXCAB02 {Rc4h}
K1COAXCAB02 L1COAXCAB02 L3COAXCAB02 {kc4}
R3COAXCAB02 N009 n004COAXCAB02 {Rc4g}
L3COAXCAB02 n004COAXCAB02 n005COAXCAB02 {Lc4g}
L4COAXCAB02 n005COAXCAB02 n006COAXCAB02 {Lc4g}
R4COAXCAB02 n006COAXCAB02 n009COAXCAB02 {Rc4g}
K2COAXCAB02 L2COAXCAB02 L4COAXCAB02 {kc4}
C1COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Cc4sh}
R5COAXCAB02 n002COAXCAB02 n005COAXCAB02 {Rc4sh}
R6COAXCAB02 n007COAXCAB02 n008COAXCAB02 {Rc4ch}
E1COAXCAB02 n009COAXCAB02 n010COAXCAB02 n007COAXCAB02 n008COAXCAB02 1
R7COAXCAB02 n010COAXCAB02 N007 {Rc4ch}
E2COAXCAB02 n008COAXCAB02 N005 n010COAXCAB02 N007 1
I1 N004 N009 {Idc} AC {Iac} 0
R1COAXCAB03 U2_adc_high n001COAXCAB03 {Rc2h}
L1COAXCAB03 n001COAXCAB03 n002COAXCAB03 {Lc2h}
L2COAXCAB03 n002COAXCAB03 n003COAXCAB03 {Lc2h}
R2COAXCAB03 n003COAXCAB03 n007COAXCAB03 {Rc2h}
K1COAXCAB03 L1COAXCAB03 L3COAXCAB03 {kc2}
R3COAXCAB03 U2_adc_low n004COAXCAB03 {Rc2g}
L3COAXCAB03 n004COAXCAB03 n005COAXCAB03 {Lc2g}
L4COAXCAB03 n005COAXCAB03 n006COAXCAB03 {Lc2g}
R4COAXCAB03 n006COAXCAB03 n009COAXCAB03 {Rc2g}
K2COAXCAB03 L2COAXCAB03 L4COAXCAB03 {kc2}
C1COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Cc2sh}
R5COAXCAB03 n002COAXCAB03 n005COAXCAB03 {Rc2sh}
R6COAXCAB03 n007COAXCAB03 n008COAXCAB03 {Rc2ch}
E1COAXCAB03 n009COAXCAB03 n010COAXCAB03 n007COAXCAB03 n008COAXCAB03 1
R7COAXCAB03 n010COAXCAB03 N011 {Rc2ch}
E2COAXCAB03 n008COAXCAB03 N013 n010COAXCAB03 N011 1
R1COAXCAB04 N019 n001COAXCAB04 {Rc1h}
L1COAXCAB04 n001COAXCAB04 n002COAXCAB04 {Lc1h}
L2COAXCAB04 n002COAXCAB04 n003COAXCAB04 {Lc1h}
R2COAXCAB04 n003COAXCAB04 n007COAXCAB04 {Rc1h}
K1COAXCAB04 L1COAXCAB04 L3COAXCAB04 {kc1}
R3COAXCAB04 N021 n004COAXCAB04 {Rc1g}
L3COAXCAB04 n004COAXCAB04 n005COAXCAB04 {Lc1g}
L4COAXCAB04 n005COAXCAB04 n006COAXCAB04 {Lc1g}
R4COAXCAB04 n006COAXCAB04 n009COAXCAB04 {Rc1g}
K2COAXCAB04 L2COAXCAB04 L4COAXCAB04 {kc1}
C1COAXCAB04 n002COAXCAB04 n005COAXCAB04 {Cc1sh}
R5COAXCAB04 n002COAXCAB04 n005COAXCAB04 {Rc1sh}
R6COAXCAB04 n007COAXCAB04 n008COAXCAB04 {Rc1ch}
E1COAXCAB04 n009COAXCAB04 n010COAXCAB04 n007COAXCAB04 n008COAXCAB04 1
R7COAXCAB04 n010COAXCAB04 U1_adc_low {Rc1ch}
E2COAXCAB04 n008COAXCAB04 U1_adc_high n010COAXCAB04 U1_adc_low 1
C2 U2_adc_high U2_adc_low {C2in}
R3 U2_adc_high U2_adc_low {R2in}
C5 U3_adc_low N003 {C3sh}
R4 U3_adc_low N003 {R3sh}
C6 U1_adc_high U1_adc_low {C1in}
R5 U1_adc_high U1_adc_low {R1in}
C9 U1_adc_low N022 {C1sh}
R6 U1_adc_low N022 {R1sh}
R1GNDLUG01 N002 n001GNDLUG01 {Rgrd3}
L1GNDLUG01 n001GNDLUG01 N003 {Lgrd3}
R1GNDLUG02 N022 n001GNDLUG02 {Rgnd1}
L1GNDLUG02 n001GNDLUG02 0 {Lgnd1}
R1GNDLUG03 N009 n001GNDLUG03 {Rsrc}
L1GNDLUG03 n001GNDLUG03 0 {Lsrc}
XZ2 N006 N008 N013 N011 N005 N007 N012 N010 N014 N014 STD4TP2 Rp={Rp2} Lp={Lp2} Rpg={Rp2r} Lpg={Lp2r} kp={kpo2} Cps={Cp2s} Rps={Rp2s} Rc={Rc2} Lc={Lc2} Rcg={Rc2r} Lcg={Lc2r} kc={kco2} Ccs={Cc2s} Rcs={Rc2s} Rs={R2} Ls={L2}
R2 N003 N001 {R3gnd}
C1 N003 N001 {C3gnd}
R1GNDLUG04 0 n001GNDLUG04 {Rgnd3}
L1GNDLUG04 n001GNDLUG04 N001 {Lgnd3}
R1COAXCAB05 U3_adc_high n001COAXCAB05 {Rc2h}
L1COAXCAB05 n001COAXCAB05 n002COAXCAB05 {Lc2h}
L2COAXCAB05 n002COAXCAB05 n003COAXCAB05 {Lc2h}
R2COAXCAB05 n003COAXCAB05 n007COAXCAB05 {Rc2h}
K1COAXCAB05 L1COAXCAB05 L3COAXCAB05 {kc2}
R3COAXCAB05 U3_adc_low n004COAXCAB05 {Rc2g}
L3COAXCAB05 n004COAXCAB05 n005COAXCAB05 {Lc2g}
L4COAXCAB05 n005COAXCAB05 n006COAXCAB05 {Lc2g}
R4COAXCAB05 n006COAXCAB05 n009COAXCAB05 {Rc2g}
K2COAXCAB05 L2COAXCAB05 L4COAXCAB05 {kc2}
C1COAXCAB05 n002COAXCAB05 n005COAXCAB05 {Cc2sh}
R5COAXCAB05 n002COAXCAB05 n005COAXCAB05 {Rc2sh}
R6COAXCAB05 n007COAXCAB05 n008COAXCAB05 {Rc2ch}
E1COAXCAB05 n009COAXCAB05 n010COAXCAB05 n007COAXCAB05 n008COAXCAB05 1
R7COAXCAB05 n010COAXCAB05 N008 {Rc2ch}
E2COAXCAB05 n008COAXCAB05 N006 n010COAXCAB05 N008 1
C4 U3_adc_low U3_adc_high {C3in}
R1 U3_adc_low U3_adc_high {R3in}
C3 U2_adc_low N016 {C2sh}
R7 U2_adc_low N016 {R2sh}
R1GNDLUG05 N015 n001GNDLUG05 {Rgrd2}
L1GNDLUG05 n001GNDLUG05 N016 {Lgrd2}
R8 N016 N017 {R2gnd}
C7 N016 N017 {C2gnd}
R1GNDLUG06 0 n001GNDLUG06 {Rgnd2}
L1GNDLUG06 n001GNDLUG06 N017 {Lgnd2}
E1 N002 0 U3_adc_low 0 1
E2 N015 0 U2_adc_low 0 1
.param Rs2_TWAXSH01={0.5*Rp111} Ls2_TWAXSH01={0.5*?} RsG2_TWAXSH01={0.5*?} LsG2_TWAXSH01={0.5*?} RsS2_TWAXSH01={0.5*?} LsS2_TWAXSH01={0.5*?}
.param Rnull_TWAXSH01=1G
.param k_lg_TWAXSH01={?/sqrt(?*?)} k_ls_TWAXSH01={?/sqrt(?*?)} k_gs_TWAXSH01={?/sqrt(?*?)} k_gg_TWAXSH01={?/sqrt(?*?)} k_ll_TWAXSH01={?/sqrt(?*?)} k_lg2_TWAXSH01={?/sqrt(?*?)}
L1TWAXSH01 N003TWAXSH01 P001TWAXSH01 {LsG2_TWAXSH01}
L2TWAXSH01 N004TWAXSH01 P002TWAXSH01 {Ls2_TWAXSH01}
L3TWAXSH01 P003TWAXSH01 N003TWAXSH01 {LsG2_TWAXSH01}
L4TWAXSH01 P004TWAXSH01 N004TWAXSH01 {Ls2_TWAXSH01}
C1TWAXSH01 N003TWAXSH01 N004TWAXSH01 ?
R1TWAXSH01 N003TWAXSH01 N004TWAXSH01 ?
R2TWAXSH01 P001TWAXSH01 NC_04 {RsG2_TWAXSH01}
R3TWAXSH01 P002TWAXSH01 NC_03 {Rs2_TWAXSH01}
R4TWAXSH01 NC_08 P004TWAXSH01 {Rs2_TWAXSH01}
R5TWAXSH01 NC_09 P003TWAXSH01 {RsG2_TWAXSH01}
L5TWAXSH01 N001TWAXSH01 P005TWAXSH01 {Ls2_TWAXSH01}
L6TWAXSH01 N002TWAXSH01 P006TWAXSH01 {LsG2_TWAXSH01}
L7TWAXSH01 P007TWAXSH01 N001TWAXSH01 {Ls2_TWAXSH01}
L8TWAXSH01 P008TWAXSH01 N002TWAXSH01 {LsG2_TWAXSH01}
C2TWAXSH01 N001TWAXSH01 N002TWAXSH01 ?
R6TWAXSH01 N001TWAXSH01 N002TWAXSH01 ?
R7TWAXSH01 P005TWAXSH01 NC_01 {Rs2_TWAXSH01}
R8TWAXSH01 P006TWAXSH01 NC_02 {RsG2_TWAXSH01}
R9TWAXSH01 NC_07 P008TWAXSH01 {RsG2_TWAXSH01}
R10TWAXSH01 NC_06 P007TWAXSH01 {Rs2_TWAXSH01}
L9TWAXSH01 CAPTWAXSH01 P009TWAXSH01 {LsS2_TWAXSH01}
L10TWAXSH01 P010TWAXSH01 CAPTWAXSH01 {LsS2_TWAXSH01}
R11TWAXSH01 P009TWAXSH01 NC_05 {RsS2_TWAXSH01}
R12TWAXSH01 NC_10 P010TWAXSH01 {RsS2_TWAXSH01}
C3TWAXSH01 N002TWAXSH01 CAPTWAXSH01 ?
C4TWAXSH01 CAPTWAXSH01 N003TWAXSH01 ?
R13TWAXSH01 CAPTWAXSH01 N003TWAXSH01 ?
R14TWAXSH01 N002TWAXSH01 CAPTWAXSH01 ?
C5TWAXSH01 N002TWAXSH01 N003TWAXSH01 ?
R15TWAXSH01 N002TWAXSH01 N003TWAXSH01 ?
R16TWAXSH01 NC_01 NC_02 {Rnull_TWAXSH01}
R17TWAXSH01 NC_02 NC_05 {Rnull_TWAXSH01}
R18TWAXSH01 NC_05 NC_04 {Rnull_TWAXSH01}
R19TWAXSH01 NC_04 NC_03 {Rnull_TWAXSH01}
R20TWAXSH01 NC_09 NC_08 {Rnull_TWAXSH01}
R21TWAXSH01 NC_10 NC_09 {Rnull_TWAXSH01}
R22TWAXSH01 NC_07 NC_10 {Rnull_TWAXSH01}
R23TWAXSH01 NC_06 NC_07 {Rnull_TWAXSH01}
.lib ZbrgLib.cir ZbrgLib

* Automatically generated stray couplings
.param k_stray001={max(min(M_stray001/sqrt(abs(Lc1h*Lc2h)),0.999),-0.999)} $ M#001=<M_stray001> - M#stray_group_id=<mutual_inductance_parameter>
Kstray0001 L1COAXCAB04 L1COAXCAB03 {k_stray001}
.param k_stray002={max(min(M_stray001/sqrt(abs(Lc1h*Lc2g)),0.999),-0.999)} $ M#001=<M_stray001> - M#stray_group_id=<mutual_inductance_parameter>
Kstray0002 L1COAXCAB04 L3COAXCAB03 {k_stray002}
.param k_stray003={max(min(M_stray001/sqrt(abs(Lc1g*Lc2h)),0.999),-0.999)} $ M#001=<M_stray001> - M#stray_group_id=<mutual_inductance_parameter>
Kstray0003 L3COAXCAB04 L1COAXCAB03 {k_stray003}
.param k_stray004={max(min(M_stray001/sqrt(abs(Lc1g*Lc2g)),0.999),-0.999)} $ M#001=<M_stray001> - M#stray_group_id=<mutual_inductance_parameter>
Kstray0004 L3COAXCAB04 L3COAXCAB03 {k_stray004}
Cstray001 n002COAXCAB04 n002COAXCAB03 {C_stray001} $ C#001=<C_stray001> - C#stray_group_id=<stray_capacitance_parameter>

.end
